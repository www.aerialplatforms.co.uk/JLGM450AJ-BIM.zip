Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-05-03T15:40:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu May 03 15:40:28 2018 * Host: CHTSP10141 * Database: C:\Users\20062089\AppData\Local\Temp\{9BFD44B5-E85D-4945-8D44-9207FF7AA98F}\ifc * Database version: 5507 * Database creation date: Thu May 03 15:40:09 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu May 03 15:40:09 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu May 03 15:40:09 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 m
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 m; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 m

# IfcTransportElement: Stowed Position, 1001164636_M450AJ:Stowed Position:6325837
In: Level 1
Type - PredefinedType: ELEVATOR; Material: JLG_Paint_Orange, JLG_Paint_Silver Grey, JLG_Plastic_Blue, JLG_Plastic_Green, JLG_Paint_Black, JLG_Plastic_Yellow, JLG_Metal Paint_White, JLG_Metal Paint_Black, JLG_Paint_Beige, JLG_Plastic_Red, JLG_Rubber_Black, JLG_Steel
Type - Constraints - A1a: 0 deg; A2a: 0 deg; AE: 0.02 m; AEa: -11.25 deg; Ja: -60 deg; Reach: 0
Type - Data - Batteries: 6v, 375Ah Deep Cycle Battery x8; Brakes: Automatic Rear Wheel Brakes; Drive Motors: Electric Traction 2.6kW; Drive Speed: 7.2 kph (4.5 mph); Electrical System: 48 v DC; Generator Fuel Tank: 15.1L (4 gal); Generator Set - Fully Automatic: Kubota OC60-E4, 4.5kW; Gradeability: 30%; Ground Clearance: 0.20 m (0 ft 8 in); Horizontal Outreach: 7.24 m (23 ft 9 in); Hydraulic Motor: 48v Perm Magnet 5.39HP; Hydraulic Pump: Internal Gear Pump (0.19 in³/rev); Hydraulic Reservoir: 22.7 L (6 gal); Jib - Overall Length: 1.24 m (4 ft 1 in); Jib - Range of articulation: 144 Degrees (+84/-60); Machine weight (ANSI): 6540 kg (14,400 lbs); Machine weight (CE): 6540 kg (14,400 lbs); Max Ground Bearing Pressure (ANSI): 7.6 kg/cm2 (110 psi); Max Ground Bearing Pressure (CE): 7.6 kg/cm2 (110 psi); Platform Capacity Unrestricted (ANSI): 230 kg (500 lbs.); Platform Capacity Unrestricted (CE): 230 kg (500 lbs.); Platform Height: 13.72 m (45 ft 0 in); Platform Rotator (Hydraulic): 180 degrees; Platform Size: 0.76 x1.22 m (2 ft 6 in x 4 ft 0 in)or (0.76 x 1.52m (2 ft 6 in x 5 ft 0 in); Swing: 360 degrees, non continuous; Turning Radius Inside: 0.61 m (2 ft 0 in); Turning Radius Outside: 3.15 m ( 10 ft 4 in); Tyres: 240/55 - 17.5 PNEU/Foam Filled; Up and Over Height: 7.70 m (25 ft 3 in)
Type - Dimensions - A1a1: 180 deg; A2a1: 180 deg; AEa1: 168.75 deg; AEHa: 0 deg; AEHa1: 180 deg; AHa: 0 deg; AHa1: 180 deg; Ja1: 120 deg; JHa: 11.25 deg; JHa1: 191.25 deg; PHa: 60 deg; PHa1: 240 deg
Type - General - Articulating Jib: 1.24 m; Platform Rotator: 180 degree powered platform rotator; Platform Side Entry: 0.76 m x 1.22 m (or) 0.76 m x 1.52 m low mount platform; Tilt Alarm/Indicator Light: 3 degrees CE, 5 degrees Japan
Type - Identity Data - Manufacturer: JLG; OmniClass Number: 23.40.00.00; OmniClass Title: Equipment and Furnishings; Type Name: Stowed Position; URL: https://www.jlg.com
Type - Model Properties - _Author: n/a; _AuthorizedBy: n/a; _BIMspec_GUID: n/a; _BimSpecGuid: n/a; _BSBibleVersion: n/a; _CreatedBy: JLG; _CurrentRevision: 0; _DistributedBy: JLG; BIMObjectName: 1001164636_M450AJ; NBSDescription: Articulating Boom Lift; NBSNote: n/a; NBSObjectName: JLG M450AJ_Articulating Boom Lift; NBSOfficeMasterTag: n/a; NBSReference: n/a
Type - Other - Category: Mechanical Equipment; AccessibilityPerformance: n/a; AssetIdentifier (default): Please Record On Commissioning; AssetType: Elevators; BarCode (default): Please Record On Commissioning; ClassificationName: n/a; ClassificationValue: n/a; CodePerformance: n/a; Color: n/a; Constituents: n/a; CreatedBy: JLG (https://www.jlg.com/en); CreatedOn: 2018; DocumentationCertificates: n/a; DocumentationInstallationGuide: n/a; DocumentationLiterature: n/a; DocumentationMaintenance: n/a; DocumentationTechnical: n/a; DurationUnit: Years; ExpectedLife: n/a; Family Name: 1001164636_M450AJ; Features: n/a; Finish: n/a; Grade: n/a; InstallationDate (default): n/a; ManufacturerName: JLG (https://www.jlg.com/en); Material: n/a; ModelNumber: M450AJ; ModelReference: JLG - Articulating Boom Lift; ProductionYear: n/a; ReferencedStandard: n/a; ReplacementCost: n/a; SerialNumber (default): Please Record On Commissioning; Shape: n/a; Size: n/a; SpareParts: n/a; TypeName: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.jlg.com; WarrantyGuarantorParts: https://www.jlg.com
OperationType: ELEVATOR; CapacityByWeight: 0 kg; CapacityByNumber: 0
Pset_ManufacturerTypeInformation - ModelReference: JLG - Articulating Boom Lift; Manufacturer: JLG; ProductionYear: n/a
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 m
Dimensions - Area: 313.146 m2; Platform Rotation: 0 deg; PR: 0 deg; Reach Diagram: no; Sa: -180 deg; Sa1: 0 deg; Swing_Angle: 0 deg; Turning Radius: no; Volume: 2.073 m3; Working Area: no
Identity Data - Mark: 147
Other - Family: 1001164636_M450AJ: Stowed Position; Family and Type: 1001164636_M450AJ: Stowed Position; Type: 1001164636_M450AJ: Stowed Position; Type Id: 1001164636_M450AJ: Stowed Position; WarrantyStartDate (default): Please Record On Commissioning
Phasing - Phase Created: New Construction
